DESCRIPTION = "Napolean is a Sphinx extension"
HOMEPAGE = "https://sphinxcontrib-napoleon.readthedocs.io/"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=36b5e5011ff2a593c7850af31f6682b7"

SRC_URI[md5sum] = "080555f8bcdf5de9819798c24bdd02f8"
SRC_URI[sha256sum] = "407382beed396e9f2d7f3043fad6afda95719204a1e1a231ac865f40abcbfcf8"

inherit setuptools3 pypi
