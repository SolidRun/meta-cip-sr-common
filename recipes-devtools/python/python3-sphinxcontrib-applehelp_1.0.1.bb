DESCRIPTION = "sphinxcontrib-applehelp is a Sphinx extension"
HOMEPAGE = "http://sphinx-doc.org/"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c7715857042d4c8c0105999ca0c072c5"

SRC_URI[md5sum] = "c3424507cc28291f8005081b6a96afb1"
SRC_URI[sha256sum] = "edaa0ab2b2bc74403149cb0209d6775c96de797dfd5b5e2a71981309efab3897"

inherit setuptools3 pypi
