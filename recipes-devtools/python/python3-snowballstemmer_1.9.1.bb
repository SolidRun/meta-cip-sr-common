DESCRIPTION = "This package provides 26 stemmers for 25 languages generated from Snowball algorithms."
HOMEPAGE = "https://github.com/snowballstem/snowball"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://PKG-INFO;beginline=8;endline=8;md5=53dbfa56f61b90215a9f8f0d527c043d"

SRC_URI[md5sum] = "00324762f8a0e6889353926e2c9767fb"
SRC_URI[sha256sum] = "713e53b79cbcf97bc5245a06080a33d54a77e7cce2f789c835a143bcdb5c033e"

inherit setuptools3 pypi
