DESCRIPTION = "An implementation of the CAN SAE J1939 standard for Python"
HOMEPAGE = "https://github.com/juergenH87/python-can-j1939"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=32e7309a8200a5f4b7aec6efcfb8e77e"

SRC_URI[md5sum] = "17046211d141f92a09aa7684798708aa"
SRC_URI[sha256sum] = "5b7895ed6bbd3276e4e43bacff357d482c33d6dc683cc89d42ef6f147bbb6d85"

inherit setuptools3 pypi
