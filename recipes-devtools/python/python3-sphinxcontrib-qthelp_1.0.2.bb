DESCRIPTION = "sphinxcontrib-qthelp is a Sphinx extension"
HOMEPAGE = "http://sphinx-doc.org/"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f7a83b72ea86d04827575ec0b63430eb"

SRC_URI[md5sum] = "3532d4643d0b1cc3806e43f59495c030"
SRC_URI[sha256sum] = "79465ce11ae5694ff165becda529a600c754f4bc459778778c7017374d4d406f"

inherit setuptools3 pypi
