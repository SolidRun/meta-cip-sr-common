DESCRIPTION = "sphinxcontrib-serializinghtml is a Sphinx extension"
HOMEPAGE = "http://sphinx-doc.org/"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=32a84ac5cd3bbd10c4d479233ad588b6"

SRC_URI[md5sum] = "6a4318d6d11c345fbc669e6a86f32766"
SRC_URI[sha256sum] = "c0efb33f8052c04fd7a26c0a07f1678e8512e0faec19f4aa8f2473a8b81d5227"

inherit setuptools3 pypi
