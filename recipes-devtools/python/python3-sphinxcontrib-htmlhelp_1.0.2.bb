DESCRIPTION = "sphinxcontrib-htmlhelp is a Sphinx extension"
HOMEPAGE = "http://sphinx-doc.org/"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=24dce5ef6a13563241c24bc366f48886"

SRC_URI[md5sum] = "f72e4b26ec0f6387d855c74819500b66"
SRC_URI[sha256sum] = "4670f99f8951bd78cd4ad2ab962f798f5618b17675c35c5ac3b2132a14ea8422"

inherit setuptools3 pypi
