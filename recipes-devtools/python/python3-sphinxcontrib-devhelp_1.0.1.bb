DESCRIPTION = "sphinxcontrib-devhelp is a Sphinx extension"
HOMEPAGE = "http://sphinx-doc.org/"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=fd30d9972a142c857a80c9f312e92b93"

SRC_URI[md5sum] = "ecb33259e2e8300493d210140af7d957"
SRC_URI[sha256sum] = "6c64b077937330a9128a4da74586e8c2130262f014689b4b89e2d08ee7294a34"

inherit setuptools3 pypi
