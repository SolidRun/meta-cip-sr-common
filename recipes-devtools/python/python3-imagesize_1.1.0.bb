DESCRIPTION = "Getting image size from png/jpeg/jpeg2000/gif file"
HOMEPAGE = "https://github.com/shibukawa/imagesize_py"
SECTION = "devel/python"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.rst;md5=0c128f0f7e8a02e1b83884c0b5a41cda"

SRC_URI[md5sum] = "2f89749b05e07c79c46330dbc62f1e02"
SRC_URI[sha256sum] = "f3832918bc3c66617f92e35f5d70729187676313caa60c187eb0f28b8fe5e3b5"

inherit setuptools3 pypi
