DESCRIPTION = "A collection of helpful Python tools!"
HOMEPAGE = "http://pygments.org/"
SECTION = "devel/python"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=349769852738650e6638ced824bff57d"

SRC_URI[md5sum] = "dcbf86ba63c19d163c37c3233e24951f"
SRC_URI[sha256sum] = "109eb91588e9cf722de98c98d300e1c5896e877f5704dc61176fa09686ca635b"

inherit setuptools3 pypi
