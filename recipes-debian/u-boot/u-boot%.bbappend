# Enable mender u-boot auto configure
MENDER_UBOOT_AUTO_CONFIGURE = "1"
