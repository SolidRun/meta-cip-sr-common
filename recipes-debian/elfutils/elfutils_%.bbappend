LICENSE = "GPLv2 & LGPLv3+ & GPLv3+"
