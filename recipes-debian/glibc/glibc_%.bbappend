do_install_append_n6gq () {
        ln -s ld-2.28.so ${D}/lib/ld-linux.so.3
}
do_install_append_n6gsdl () {
        ln -s ld-2.28.so ${D}/lib/ld-linux.so.3
}
do_install_append_in6gq () {
        ln -s ld-2.28.so ${D}/lib/ld-linux.so.3
}
do_install_append_in6gsdl () {
        ln -s ld-2.28.so ${D}/lib/ld-linux.so.3
}
do_install_append_solidsense () {
        ln -s ld-2.28.so ${D}/lib/ld-linux.so.3
}
