# Update checksum
#  QA Issue: linux-libc-headers-base: The LIC_FILES_CHKSUM does not match for file://COPYING;md5=bbea815ee2795b2f4230826c0c6b8814
#  linux-libc-headers-base: The new md5 checksum is d7810fab7487fb0aad327b76f1be7cd7

LIC_FILES_CHKSUM = "file://COPYING;md5=bbea815ee2795b2f4230826c0c6b8814"

DEPENDS = " \
	rsync-native \
"
