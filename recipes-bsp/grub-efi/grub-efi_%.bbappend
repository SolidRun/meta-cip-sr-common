FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://debian_patches_fix-yylex-build.patch \
"
